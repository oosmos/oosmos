<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Blink.ewp</path>
  </project>
  <batchBuild />
</workspace>
